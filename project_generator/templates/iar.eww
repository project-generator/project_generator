<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path></path>
	</project>
	<batchBuild></batchBuild>
</workspace>